# Keil uVision project stm32f103_exflash_flm.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_exflash_flm +hex
  AfterMake: cmd /c copy ".\Objects\STM32F103RCT6_W25Q64.axf" ".\Binary\W25Q64_STM32F103.FLM"
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\STM32F103_exflash_flm
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Objects\stm32f103_exflash_flm.sct
  group source
    ./: FlashDev.c FlashPrg.c
